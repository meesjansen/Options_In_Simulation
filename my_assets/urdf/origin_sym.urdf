Commit message: try

File: my_assets/urdf/origin_sym.urdf (robot description, URDF)
Before this commit: robot symmetric_skid_steer, 5 links, 4 joints
Joints:
- joint right_front_wheel_joint: axis 0 0 1 -> 0 0 -1
- joint right_rear_wheel_joint: axis 0 0 1 -> 0 0 -1
