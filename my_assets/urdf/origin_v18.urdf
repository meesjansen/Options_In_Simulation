Commit message: test husky

File: my_assets/urdf/origin_v18.urdf (robot description, URDF)
Before this commit: robot avular_origin_v10, 8 links, 7 joints
Links:
- removed link camera_link
Joints:
- removed joint realsense_joint
